# Keil uVision project agv_motor.uvprojx, settings and files
target agv_motor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F456RCT7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x1B000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: agv_motor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F456RCT7,USE_STDPERIPH_DRIVER,AT_START_F456_V1,USE_FREERTOS,USE_I2C_2V8
  c include: ..\src;..\..\agv-motion-contract\include;..\libraries\drivers\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\inc;..\at32f45x_board;..\third_party\bosch_bmi270;..\third_party\st_vl53l0x;..\third_party\freertos\include;..\third_party\freertos\portable\rvds\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1b000
  group production
    ../src/: at32f45x_clock.c at32f45x_int.c main.c app_freertos.c debug_uart_log.c motion_command.c motion_reference_receiver.c motion_reference_control.c debug_uart_transport.c serial_motion_protocol.c chassis_motion_controller.c chassis_heading_fusion.c magnetic_follow_controller.c imu_heading.c motor_driver.c motor_pid.c motor_speed_control.c adc_monitor.c motor_encoder.c canfd_protocol.c canfd_status_codec.c motor_current.c tof_i2c3.c dock_tof_sensor.c dock_ir_receiver.c pn532_uart5.c rfid_record.c bumper_input.c bumper_safety.c
  group bsp
    ../at32f45x_board/: at32f45x_board.c
  group third_party
    ../third_party/bosch_bmi270/: bmi2.c bmi270.c
    ../third_party/st_vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform.c
  group freertos
    ../third_party/freertos/: tasks.c list.c queue.c
    ../third_party/freertos/portable/rvds/ARM_CM4F/: port.c
  group firmware
    ../libraries/drivers/src/: at32f45x_adc.c at32f45x_can.c at32f45x_crm.c at32f45x_exint.c at32f45x_flash.c at32f45x_gpio.c at32f45x_misc.c at32f45x_pwc.c at32f45x_scfg.c at32f45x_tmr.c at32f45x_usart.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f45x.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f45x.s
  group readme
    ../: README.md
